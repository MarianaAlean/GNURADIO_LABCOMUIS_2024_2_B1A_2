options:
  parameters:
    author: Mariana_Alean_Daiver_Corredor
    generate_options: qt_gui
    id: Lab1_punto2
    output_language: python
    title: Lab1_Punto2_Muestreo
  states: {}

blocks:
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    start: '2000'
    step: '1000'
    stop: '40000'
    value: '2000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '90000'
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '2000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '128'
    srate: samp_rate
    stemplot: 'True'
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.9.8.0
