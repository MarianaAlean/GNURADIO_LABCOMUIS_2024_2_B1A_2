options:
  parameters:
    generate_options: qt_gui
    id: lab3_2
    output_language: python
    title: Modulador  de amplitud
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: amplitud de l aportadora
    start: '0'
    step: '1E-3'
    stop: '1'
    value: '125E-3'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud del mensaje
    start: '0'
    step: '100E-3'
    stop: '4'
    value: '1'
  states: {}
- name: B
  id: variable_qtgui_range
  parameters:
    label: cambio de banda
    start: '-1'
    step: '2'
    stop: '1'
    value: '1'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: ganancia del tranmisor
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: frecuencia de la portadora
    start: 50E6
    step: 1E6
    stop: 2.2E9
    value: 50E6
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: frecuencia del mensaje
    start: '300'
    step: '100'
    stop: samp_rate/4
    value: 1E3
  states: {}
- name: ka
  id: variable_qtgui_range
  parameters:
    label: habilita portadora (Ka)
    start: '0'
    step: '0.1'
    stop: '2'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.5625E6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: ka
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: Ac
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_1, '0', uhd_usrp_sink_0, '0']
- [blocks_null_source_0, '0', blocks_float_to_complex_0, '1']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-810-g1ecb8565
